# Repository shtsno24/MicroCar

## KiCad design schematic/schematic/schematic.kicad_pcb

Parts:
BT1: LiPo; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
C1, C2, C7, C12, C16, C17, C19, C20, C25: 10u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C3: 100u; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
C4, C6, C8, C11, C13, C14, C15, C18, C21, C22, C23, C24, C27: 0.1u; C_0402_1005Metric_HandSoldering
C5: 10p; C_0402_1005Metric_HandSoldering
C9: 4.7u; C_0402_1005Metric_HandSoldering
C10: 10u; C_0402_1005Metric_HandSoldering
C26: 22u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1, D2: SS2040FL; D_SOD-123F
D3, D5: LED_Brake; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: LED_Charge; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6: OSTB0603C1C-A
D7: LED_Right; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D8: LED_MD; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D9: LED_5V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D10: LED_Left; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: SMD1812P125TS; R_1812_4532Metric_Pad1.30x3.40mm_HandSolder
IC1: DRV8830; MSOP-10-1EP_3x3mm_P0.5mm_EP1.68x1.88mm_DRV8830
J1, J3, J8: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J2: USB_B_Micro; USB_Micro-B_Amphenol_10103594-0001LF_Horizontal
J4: Conn_M5StickV; PinSocket_1x04_P2.54mm_Vertical
J5: Conn_I2C; PinHeader_1x04_P2.54mm_Vertical
J6, J7: Conn_Tale; PinHeader_1x05_P2.54mm_Vertical
J9, J10, J11, J12, J13, J14, J17, J18: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
J15, J16: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J19: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
JP1: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L1, L2, L3: 2.2u; SPM3015-xRxM-LR
M1: M_Small; PinSocket_1x02_P2.54mm_Vertical
Q1, Q5: IRLML6402; SOT-23
Q2, Q3: SS8050; SOT-23
Q4, Q6, Q7: PJE260N02; SOT-416
Q8: BSS138; SOT-23; MPN BSS138; Digi-Key_PN BSS138CT-ND
R1: 100k; C_0402_1005Metric_HandSoldering
R2, R3, R4, R5, R6, R10, R11, R19, R22, R24, R25, R26, R27, R28, R29, R30, R31, R32: 10k; C_0402_1005Metric_HandSoldering
R7, R8: 10k; R_0402_1005Metric_HandSoldering
R9, R12, R13, R14, R15, R16, R18, R20, R21, R23: 1k; C_0402_1005Metric_HandSoldering
R17: 10m; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
SW1: SW_EN; SW_SPST_PTS810_HandSoldering
SW2: SW_IO0; SW_SPST_PTS810_HandSoldering
SW3: SW_SPDT; PinSocket_1x03_P2.54mm_Vertical
U1: TPS63002; WSON-10-1EP_2x3mm_P0.5mm_EP0.84x2.4mm_TPS6300x
U2: MPU-9250; InvenSense_QFN-24_3x3mm_P0.4mm_HandSoldering
U3: MCP73831-5-OT; SOT-23-5
U4, U6: TPS63001; WSON-10-1EP_2x3mm_P0.5mm_EP0.84x2.4mm_TPS6300x
U5: FT231XS; SSOP-20_3.9x8.7mm_P0.635mm
U7: INA219AIDCNR; SOT-23-8_Handsoldering; MPN INA219AIDCNR; Digi-Key_PN 296-23770-1-ND
U8: ESP32-WROOM-32D_GND_39; ESP32-WROOM-32_Hand
U9: PCA9306DC1; VSSOP-8_2.3x2mm_P0.5mm_hand_solder

Connections:
+3.3VA: C10.1, C13.1, C16.1, C26.2, C27.1, Q8.1 (G), R7.2, R24.2, R26.1, R27.1, R29.1, U4.1 (VOUT), U4.10 (FB), U5.3 (VCCIO), U5.13 (3V3OUT), U5.14 (~RESET), U5.15 (VCC), U8.2 (VDD), U9.2
+5V: C2.1, C4.2, C7.1, C18.1, C21.1, C22.1, D9.2 (A), J1.2, J5.3, J15.2, J16.2, R8.2, R17.2, R18.1, R28.2, R30.1, U1.1 (VOUT), U1.10 (FB), U7.1 (IN+), U7.4 (VS), U9.7, U9.8
+BATT: C1.1, C12.1, C17.1, J12.1, J13.1, J15.1, J16.1, Q5.3 (D), U1.5 (VIN), U1.6 (EN), U1.7 (PS/SYNC), U1.8 (VINA), U4.5 (VIN), U4.6 (EN), U4.7 (PS/SYNC), U4.8 (VINA), U6.5 (VIN), U6.6 (EN), U6.7 (PS/SYNC), U6.8 (VINA)
ADC1_Batt: C15.1, J3.3, J8.3, R3.2, R4.1, U8.26 (IO4)
CBUS1: R20.1, U5.17 (CBUS1)
CBUS2: R12.1, U5.10 (CBUS2)
D+: J2.3 (D+), J3.1, J8.1, U5.11 (USBDP)
D-: J2.2 (D-), J3.2, J8.2, U5.12 (USBDM)
DTR: Q3.2 (E), R5.2, U5.1 (~DTR)
EN: C11.1, C23.1, Q2.3 (C), R27.2, SW1.1, U8.3 (EN)
ESP32_RX: J4.4, U8.27 (IO16)
ESP32_TX: J4.3, U8.28 (IO17)
FAULTn: D8.1 (K), IC1.6 (FAULTn)
GND: C24.1, C25.1, IC1.2 (ISENSE), IC1.5 (GND), IC1.11 (GND_pad), JP1.1
GNDD: BT1.2 (-), C1.2, C2.2, C3.2, C4.1, C5.2, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C22.2, C23.2, C26.1, C27.2, IC1.7 (A0), IC1.8 (A1), J1.1, J2.5 (GND), J2.6 (Shield), J4.1, J5.4, J6.5, J7.5, J9.1, J10.1, J11.1, J14.1, JP1.2, Q4.2 (S), Q6.2 (S), Q7.2 (S), R1.1, R2.2, R4.2, R11.2, R13.2, R19.2, R21.2, R22.2, R25.1, R31.1, R32.1, SW1.2, SW2.2, SW3.1 (A), U1.3 (PGND), U1.9 (GND), U1.11 (GND), U2.18 (GND), U2.20 (RESV_GND), U3.2 (VSS), U4.3 (PGND), U4.9 (GND), U4.11 (GND), U5.6 (GND), U5.16 (GND), U6.3 (PGND), U6.9 (GND), U6.11 (GND), U7.3 (GND), U7.7 (A0), U7.8 (A1), U8.1 (GND), U8.15 (GND), U8.38 (GND), U8.39 (GND_PAD), U9.1
GPIO_32: J19.1, U8.8 (IO32)
GPIO_33: J19.2, U8.9 (IO33)
I2C_SCL: R24.1, U8.11 (IO26), U9.3
I2C_SCL_5V: IC1.10 (SCL), J5.2, J15.4, J16.4, R30.2, U7.5 (SCL), U9.6
I2C_SDA: R26.2, U8.10 (IO25), U9.4
I2C_SDA_5V: IC1.9 (SDA), J5.1, J15.3, J16.3, R28.1, U7.6 (SDA), U9.5
IMU_CS: R32.2, U2.22 (~CS), U8.23 (IO15)
IO0: C14.1, Q3.3 (C), R29.2, SW2.1, U8.25 (IO0)
LED_BRAKE: J6.2, J7.2, Q4.1 (G), R11.1, U8.30 (IO18)
LED_LEFT: J6.3, J7.3, Q7.1 (G), R22.1, U8.31 (IO19)
LED_RIGHT: J6.1, J7.1, Q6.1 (G), R19.1, U8.29 (IO5)
MD_VM: C21.2, C24.2, C25.2, IC1.4 (VCC), R17.1, U7.2 (IN-)
unnamed: C8.1, U2.10 (REGOUT)
unnamed: D1.2 (A), J2.1 (VBUS)
unnamed: D2.1 (K), F1.1, Q1.2 (S)
unnamed: D3.1 (K), R9.1
unnamed: D4.2 (A), R14.2
unnamed: D5.1 (K), R15.1
unnamed: D6.2 (Red), R20.2
unnamed: D6.3 (Blue), R12.2
unnamed: D6.4 (Green), R13.1
unnamed: D7.1 (K), R16.1
unnamed: D8.2 (A), R18.2
unnamed: D9.1 (K), R21.1
unnamed: D10.1 (K), R23.1
unnamed: F1.2, Q5.2 (S), R10.1
unnamed: IC1.1 (OUT2), M1.1
unnamed: IC1.3 (OUT1), M1.2
unnamed: L1.1, U1.4 (L1)
unnamed: L1.2, U1.2 (L2)
unnamed: L2.1, U4.4 (L1)
unnamed: L2.2, U4.2 (L2)
unnamed: L3.1, U6.4 (L1)
unnamed: L3.2, U6.2 (L2)
unnamed: Q2.1 (B), R5.1
unnamed: Q3.1 (B), R6.1
unnamed: Q4.3 (D), R9.2, R15.2
unnamed: Q5.1 (G), R10.2, SW3.2 (B), SW3.3 (C)
unnamed: Q6.3 (D), R16.2
unnamed: Q7.3 (D), R23.2
unnamed: R2.1, U3.5 (PROG)
unnamed: R31.2, U8.24 (IO2)
PWM0: Q8.2 (S), R7.1, U8.12 (IO27)
PWM0_5V: J1.3, J17.1, J18.1, Q8.3 (D), R8.1
RTS: Q2.2 (E), R6.2, U5.2 (~RTS)
SPI_CLK: U2.23 (SCL/SCLK), U8.13 (IO14)
SPI_MISO: R25.2, U2.9 (AD0/MISO), U8.14 (IO12)
SPI_MOSI: U2.24 (SDA/MOSI), U8.16 (IO13)
STAT: D4.1 (K), U3.1 (STAT)
UART_RX: U5.20 (TXD), U8.34 (RXD0/IO3)
UART_TX: U5.4 (RXD), U8.35 (TXD0/IO1)
VBAT: BT1.1 (+), C9.1, Q1.3 (D), R3.1, U3.3 (VBAT)
VBUS: C3.1, D1.1 (K), D2.2 (A), Q1.1 (G), R1.2, R14.1, U3.4 (VDD)

Notes on the sheet:
M5StickV
Charge
+3.3V
+5V
Boot
Indicators
ESP32
Switch
Servo
Motor
GPIO
I2C
LiPo
IMU

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
Board: 2 copper layers, 66.1 x 43.0 mm, 116 parts (46 on the bottom side), 69 nets.

## Commit log

2019-12-31 にゃーん
2020-01-04 Try ToF Sensor
2020-01-05 Drawing Circuit
2020-01-05 drawing schematic(still remain servo)
2020-01-05 take some screen shots
2020-01-06 Drawing Circuit (Add some indicators)
2020-01-06 回路書き終わった．
2020-01-06 add USB-A port
2020-01-07 remove ESP_LED
2020-01-07 ToF Test has done
2020-01-09 Create IMU_Test
2020-01-13 Accelometer Test has done
2020-01-14 assign footprint
2020-01-14 wip: add another layer
2020-01-14 配置開始
2020-01-15 Pin Assign test
2020-01-15 地獄の配線
2020-01-15 一歩進んで仕様決めなおし
2020-01-15 ちょっとシンプルにしよう
2020-01-15 Change MD to DRV8830
2020-01-18 やっぱり機能を絞るに限る
2020-01-18 ビアをいっぱい打ち込んだ
2020-01-18 とりあえずのデータは完成
2020-01-19 サーボとIMUが動いた
2020-01-20 基板発注
2020-01-25 Create Test Code for GS1502
2020-01-29 Add Test Code for DRV8830
2020-01-31 Add Test Code for INA219
2020-02-03 ____
2020-02-15 Add New Images
2020-02-16 Refactor Tof_Test.ino
2020-02-17 Update STL Files
2020-02-18 Update Drive Shaft
2020-03-03 Organize Folders
2020-06-18 update gitignore
2020-06-18 Update Board
2020-06-20 add new schematic
2020-07-18 ToDo : IMU Range Settings
2020-07-22 Improve Frame Rate
2020-07-23 update view_test
2020-07-24 Add Line Graph Class
2020-07-27 DRV8830 is WORKING
2020-08-01 Add INA219's Setup Guide
2020-08-03 ToDo: Check Current Values
2020-08-04 Check Current Values :Done
2020-08-05 Add Servo
2020-11-14 remove cache
2020-11-14 MOD gitignore
2020-11-14 test
2020-11-14 ADD : Generate Model
2020-11-14 Update ignore file
2020-11-14 Using 3x3 Kernels insted of 5x5 Kernels
2020-11-18 MOD : Update ignore files
2020-11-18 MOD : model
2020-12-16 TODO : New Schematic
